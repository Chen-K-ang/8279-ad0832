# Keil uVision project 程序.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  group user
    ./User/: LCD1602.c delay.c ADC0832.c main.c time.c U8279.c
